# Keil uVision project AI8051U-Dhrystone-UART.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: AI8051U-Dhrystone-UART +hex
  link misc: REMOVEUNUSED
  group Dhrystone
    ./dhrystone/: dhry_1.c dhry_2.c
  group Source Group 1
    ./src/: main.c STC32G_Delay.c STC32G_NVIC.c STC32G_Timer.c UART_utils.c Timer_utils.c
